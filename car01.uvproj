# Keil uVision project car01.uvproj, settings and files
target car01 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: car01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./: STARTUP.A51 main.c
  group HARDWARE
    ./: motor.c serial.c velometer.c ultrosonic.c
  group SYSTEM
    ./: delay.c
